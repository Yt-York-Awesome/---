# Keil uVision project atk_f103.uvprojx, settings and files
target ATK_MD0240 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares;..\..\BSP;..\..\BSP\DHT11;..\..\BSP\JiaShiQi;..\..\BSP\ESP8266;..\..\BSP\Common;..\..\BSP\USART2;..\..\BSP\SysTick;..\..\BSP\Page;..\..\BSP\direct;..\..\BSP\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ATK_MD0240/: atk_md0240.c atk_md0240_spi.c
  group Readme
    ../../: readme.txt
  group BSP
    ../../BSP/DHT11/: dht11.c
    ../../BSP/JiaShiQi/: JSQ.c
    ../../BSP/ESP8266/: bsp_esp8266_test.c bsp_esp8266_mqtt.c bsp_esp8266.c
    ../../BSP/Common/: Common.c
    ../../BSP/USART2/: bsp_debug_usart.c
    ../../BSP/SysTick/: bsp_SysTick.c
    ../../BSP/Page/: Page.c
    ../../BSP/direct/: direct.c
    ../../BSP/TIMER/: timer.c
